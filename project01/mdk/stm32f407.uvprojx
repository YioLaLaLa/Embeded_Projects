# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\board;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\driver\usart;..\driver\I2C;..\driver\AHT20;..\driver\delay;..\driver\SPI;..\display\st7789;..\display\font;..\display\image;..\driver\esp32;..\driver\rtc;..\driver\common;..\util;..\app;..\page
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group board
    ..//board//: board.c board.h
  group app
    ../app/: main.c config.h weather.c weather.h
  group page
    ../page/: page.h welcome.c wifi_connecting.c wifi_error.c main_page.c
  group driver
    ../driver/usart/: usart.c usart.h
    ../driver/I2C/: i2c.c i2c.h
    ../driver/AHT20/: aht20.c aht20.h
    ../driver/delay/: delay.c delay.h
    ../driver/SPI/: SPI.c SPI.h
    ../display/st7789/: st7789.c st7789.h
    ../display/font/: font.c font.h font16.c font52.c font20.c
    ../display/image/: image.h main_bg.c wifi_error_page.c
    ../display/image/batch/: status_wifi_20x20.c status_wifi_off_20x20.c period_day_20x20.c period_night_20x20.c weather_sunny_44x44.c weather_partly_cloudy_44x44.c weather_cloudy_44x44.c weather_light_rain_44x44.c weather_heavy_rain_44x44.c weather_snow_44x44.c weather_fog_44x44.c weather_thunderstorm_44x44.c data_thermometer_24x24.c data_humidity_24x24.c
    ../driver/esp32/: esp32.c esp32.h
    ../driver/rtc/: rtc.c rtc.h
    ../driver/common/: datetime.h sensor.h
  group util
    ../util/: json.c json.h
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
